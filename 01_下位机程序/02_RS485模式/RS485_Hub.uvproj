# Keil uVision project RS485_Hub.uvproj, settings and files
target RS485_Hub (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 485_Relay +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\common\inc;..\04_音效模块
  group Source Group 1
    ./: main_hub.c
    ../common/: STC_BSP.lib
