# Keil uVision project HEX_A.uvproj, settings and files
target HEX_A_IR_Tx (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: IR_Player2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: WIRELESS_TX
  c include: ..\..\common\inc;..\..\04_音效模块
  group Source Group 1
    ./: main.c
    ../../common/: STC_BSP.lib
    ../../04_音效模块/: sound_effect.c
