# Keil uVision project BT_Player1.uvproj, settings and files
target BT_Player1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: BT_Player1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: PLAYER_ID=1
  c include: ..\..\01_下位机程序\common\inc;..\..\01_下位机程序\04_音效模块
  group Source Group 1
    ./: main.c
    ../../01_下位机程序/common/: STC_BSP.lib
    ../../01_下位机程序/04_音效模块/: sound_effect.c
