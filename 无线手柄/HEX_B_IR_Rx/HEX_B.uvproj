# Keil uVision project HEX_B.uvproj, settings and files
target HEX_B_IR_Rx (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Wireless_RX +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: WIRELESS_RX
  c include: .\inc
  group Source Group 1
    ./: main.c STC_BSP.lib
