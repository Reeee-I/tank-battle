# Keil uVision project RS485_Handle1.uvproj, settings and files
target RS485_Handle1 (MCS-51)
  device: STC15F2K60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 485_Player1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: PLAYER_ID=1
  c include: ..\MCU\inc
  group Source Group 1
    ./: main_handle.c
    ../MCU/: STC_BSP.lib
